## boards/shields/astramki/Kconfig.defconfig
```kconfig
if SHIELD_ASTRAMKI

config ZMK_KEYBOARD_NAME
    default "astramki"

endif # SHIELD_ASTRAMKI
```
